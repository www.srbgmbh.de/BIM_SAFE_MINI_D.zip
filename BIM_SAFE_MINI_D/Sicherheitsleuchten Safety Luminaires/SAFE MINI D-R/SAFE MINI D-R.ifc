Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-10-18T15:26:07+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: SAFE MINI D-R:SAFE MINI D-R - 280 lm - Zentralbatterie, SAFE MINI D-R:SAFE MINI D-R - 280 lm - Zentralbatterie:2487278
In: Default
Type - Material: <Unnamed>
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: SAFE MINI D-R - 280 lm - Zentralbatterie; sets with these values: 2
